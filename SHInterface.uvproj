# Keil uVision project SHInterface.uvproj, settings and files
target MCB1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: SHInterface +hex
  c flags: Optim=4
  c include: ..\SHInterface;.\basic_libs;.\cmsis_core;.\cmsis_libs;.\cmsis_starup\startup;.\cmsis_starup;.\inouts;.\inouts\SD;.\main;.\tcpnet_config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --show_parent_lib --show_full_path
  group main
    ./main/: SHInterface.c
  group cmsis_startup
    ./cmsis_starup/: EMAC_LPC17xx.c SPI_LPC17xx.c startup_LPC17xx.s system_LPC17xx.c
  group cmsis_core
    ./cmsis_core/: core_cm3.c
  group cmsis_libs
    ./cmsis_libs/: lpc17xx_adc.c lpc17xx_clkpwr.c lpc17xx_exti.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_spi.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c
  group inouts
    ./basic_libs/: adc-landtiger.c
    ./inouts/: analog_to_digit_conv.c digit_out.c encoder_read.c exti.c IAP.c pwm_write.c usb.c
  group tcpnet_config
    ./tcpnet_config/: data_provider.c peripheral_conf.c peripherals.c TCP_CM3.lib Net_Config.c TCPD_CM3.lib Net_Debug.c
  group read
    ./abstract/: Abstract.txt
